# Keil uVision project Uebung04.uvprojx, settings and files
target Apus Board (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072VBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Uebung04
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\PACK\Keil\STM32F0xx_DFP\2.0.0\Drivers\CMSIS\Device\ST\STM32F0xx\Include;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.4.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source
    ./: STM32F072VB.s main.c LCD.c LCD.h Adc.c Adc.h Font.c Platform.h Gpio.c Gpio.h
